# Keil uVision project BlinkLED_Printf.uvprojx, settings and files
target BlinkLED_Printf (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MS32F031A6A0ZWx Sinomcu
  pack: Sinomcu.MS32F0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BlinkLED_Printf +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: MS32F031
  c include: ..\..\chip\ms32f0xx\include;..\..\core;..\..\library\ms32f0xx\include;..\..\system;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../../chip/ms32f0xx/source/arm/: startup_ms32f031.s
    ../../chip/ms32f0xx/source/: system_ms32f0xx.c
  group USER
    ../system/: main.c ms32f0xx_it.c SysTick_Delay.c
    ../USER/: GPIO_CFG.c USART1_CFG.c
  group library
    ../../library/ms32f0xx/source/: ms32f0xx_adc.c ms32f0xx_comp.c ms32f0xx_crc.c ms32f0xx_dma.c ms32f0xx_exti.c ms32f0xx_flash.c ms32f0xx_gpio.c ms32f0xx_i2c.c ms32f0xx_iwdg.c ms32f0xx_opamp.c ms32f0xx_pwr.c ms32f0xx_rcc.c ms32f0xx_rtc.c ms32f0xx_spi.c ms32f0xx_tim.c ms32f0xx_usart.c ms32f0xx_utils.c ms32f0xx_wwdg.c
